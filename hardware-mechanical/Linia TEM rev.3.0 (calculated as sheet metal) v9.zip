# Autodesk Inventor part: srodek
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2023-02
Part Number: srodek
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: srodek
Author: AdminForWorker
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
